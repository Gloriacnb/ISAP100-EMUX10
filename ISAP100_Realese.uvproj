# Keil uVision project ISAP100_Realese.uvproj, settings and files
target LPC3250 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: ISAP100_Release
  AfterMake: fromelf --bin --output ./bin/ISAP100_Release.bin ./UV4Build/ISAP100_Release.axf
  c flags: Optim=1 wLevel=1
  c define: STDIO
  c misc: --exceptions
  c include: .\Src\lpc\include;.\Src\lpc32xx\include;.\Src\RTX_Config;.\Src\MidWare\include;.\Src\Application\Task;.\Src\MidWare\CLI_Commands;.\Src\MidWare\EZwellChipDriver;.\Src\MidWare\RaycomChipDriver;.\Src\MidWare\EthRTL8306E;.\Src\MidWare\s1l\include;.\Src\SNMP\Depend;.\Src\SNMP;.\Src\SNMP\SNMPMib\include;.\Src\SNMP\SNMPMib;.\Src\Application\BaseClass;.\Src\Application\DeviceComponent;.\Src\Application\DeviceComponent\BusinessResource;.\Src\Application\DeviceComponent\BusinessResource\E1Module;.\Src\Application\DeviceComponent\BusinessResource\E1Module\E1Alarm;.\Src\Application\DeviceComponent\BusinessResource\E1Module\E1MIB;.\Src\Application\DeviceComponent\CrossConnectionModule;.\Src\Application\DeviceComponent\SlotCard;.\Src\Application\Reference\Hardware\SaveInterface;.\Src\Application\Tools;.\Src\Application\Reference;.\Src\Application\Reference\Hardware\Flash\HistoryStore;.\Src\Application\Reference\Hardware;.\Src\Application\Reference\AlarmModule;.\Src\Application\Reference\Hardware\Flash;.\Src\Application\Reference\FromZLG;.\Src\SNMP\SNMPMib\E1MIB;.\Src\Application\BaseClass;.\Src\Application\DeviceComponent\BusinessResource\SDHModule;.\Src\SNMP\SNMPMib\Private\ModuleGroup;.\Src\Application\DeviceComponent\Chips;.\Src\UpDataMain;.\Src\Application\DeviceComponent\BusinessResource\EthModule;.\Src\Application\SoftSwitch;.\Src\Application\TopologyModule;.\Src\SNMP\SNMPMib\Private\ElementGroup;.\Src\Application\AlarmModule;.\Src\Application\AlarmSite;.\Src\Application\DeviceComponent\BusinessResource\TSModule;.\Src\SNMP\SNMPMib\Private\AlarmGroup;.\Src\SNMP\SNMPMib\Private\Performance
  asm define: RAM_INTVEC REMAP
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: .\UV4Build\ISAP100_Realese.sct
  group Src_Application
    ./Src/Application/: ISAP_RTX.cpp SNMP_Process.cpp
  group Src_Lib
    ./Src/Lib/: FS_ARM_L.lib TCPD_ARM_L.lib TCP_ARM_L.lib Net_lib.c
  group Src_RTX_Config
    ./Src/RTX_Config/: Net_Config.c Net_Debug.c RTX_Config.c Retarget.c IRQ.c TFTP_uif.c fs_time.c RTX_Swi.c SWI_Table.s SNMP_MIB.c File_Config.c
  group Src_lpc32xx
    ./Src/lpc32xx/: LPC32_EMAC.c NAND_LPC32xx.c
  group Src_lpc32xx_source
    ./Src/lpc32xx/source/: lpc32xx_adc_driver.c lpc32xx_clcdc_driver.c lpc32xx_clkpwr_driver.c lpc32xx_dma_driver.c lpc32xx_gpio_driver.c lpc32xx_hstimer_driver.c lpc32xx_hsuart_driver.c lpc32xx_i2c_driver.c lpc32xx_i2s_driver.c lpc32xx_intc_driver.c lpc32xx_kscan_driver.c lpc32xx_mlcnand_driver.c lpc32xx_mstimer_driver.c lpc32xx_mstr_i2c_driver.c lpc32xx_pwm_driver.c lpc32xx_rtc_driver.c lpc32xx_sdcard_driver.c lpc32xx_slcnand_driver.c lpc32xx_spi_driver.c lpc32xx_ssp_driver.c lpc32xx_timer_driver.c lpc32xx_tsc_driver.c lpc32xx_uart_driver.c lpc32xx_vectors.s lpc32xx_wdt_driver.c lpc3xxx_spwm_driver.c
  group Src_lpc_source
    ./Src/lpc/source/: lpc_api.c lpc_arm922t_cp15_driver.c lpc_bmp.c lpc_colors.c lpc_fat16.c lpc_fat16_private.c lpc_fonts.c lpc_heap.c lpc_helvr10.c lpc_lbecc.c lpc_lcd_params.c lpc_line_parser.c lpc_nandflash_params.c lpc_rom8x16.c lpc_rom8x8.c lpc_swim.c lpc_swim_font.c lpc_swim_image.c lpc_winfreesystem14x16.c lpc_x5x7.c lpc_x6x13.c lpc_string.c
  group Startup
    ./Startup/: LPC32x0_arm.s
  group Src_Application_Task
    ./Src/Application/Task/: Task_CLI.cpp Task_OnlineCheck.cpp Task_EthernetRcv.cpp Task_Reset.cpp Task_led.cpp Task_Led_E1.cpp Task_config_store.cpp Task_alarm.cpp Task_aging.cpp Taskwdt.cpp ActiveUinterface.cpp
  group Src_Drivers_RTX
    ./Src/Drivers_RTX/: Serial.cpp
  group Src_MidWare
    ./Src/MidWare/: Mid_CLI.c TerminalUart.c FVIdt821054Access.c Mid_I2C.c Mid_RC6400App.c Mid_RC7880A1App.c Mid_SMI.c Mid_SPI.c Pcm821054.cpp Mid_NandFlash.c Mid_FlashData.c ISAP100Led.cpp MidWatchDog.cpp MidMC145572.cpp Mid_power_voltage.cpp Mid_ADC.c MidoptDCC.cpp
  group Src_MidWare_CLI_Commands
    ./Src/MidWare/CLI_Commands/: CLI_Config_cmd_group.cpp CLI_Debug_cmd_group.cpp CLI_File_cmd_group.cpp
  group Src_MidWare_EZwellChipDriver
    ./Src/MidWare/EZwellChipDriver/: Chip4E1Logic.c Chip8VFLogic.c ChipGluLogic.c ChipOptLogic.c ChipSlotLogic.c ChipLM75A.cpp Chip8DataLogic.cpp Chip2BDLogic.cpp
  group Src_MidWare_EthRTL8306E
    ./Src/MidWare/EthRTL8306E/: rtk_api.c rtl8306e_asicdrv.c CSwitchBaseImpl.cpp RTL8306ESwitch.cpp
  group Src_MidWare_RaycomChipDriver
    ./Src/MidWare/RaycomChipDriver/: RC6400.c rc7880RegDriverFuncLib.c
  group Src_MidWare_s1l_source
    ./Src/MidWare/s1l/source/: s1l_cmds.c s1l_line_input.c
  group Src_SNMP
    ./Src/SNMP/: CSnmpCell.cpp CSnmpCommand.cpp CSnmpDataInOut.cpp CSnmpStatic.cpp CSnmpVariable.cpp CSnmpVariableBinding.cpp
  group Src_SNMP_Depend
    ./Src/SNMP/Depend/: CThreadTask.cpp CUDPData.cpp CClassPointer.cpp
  group Src_SNMP_SNMPMib
    ./Src/SNMP/SNMPMib/: CMibColumn.cpp CMibEntry.cpp CMibImpl.cpp CMibNodeObject.cpp CSnmpMib.cpp CMibGroup.cpp CMibTable.cpp CMibTableColumn.cpp
  group Src_SNMP_SNMPMib_Private_AttributeGroup
    ./Src/SNMP/SNMPMib/Private/AttributeGroup/: CMibAttribute.cpp CMibBasicAttribute.cpp CMibCommunicationAttribute.cpp CMibDateAttribute.cpp CMibVersionInfoTable.cpp
  group Src_SNMP_SNMPMib_Standard
    ./Src/SNMP/SNMPMib/Standard/: CStdSystem.cpp
  group Src_Application_BaseClass
    ./Src/Application/BaseClass/: CMSSave.cpp AlarmElement.cpp CifSTMAlarmStatus.cpp CifVC12AlarmStatus.cpp CifVCGAlarmStatus.cpp RealPortBase.cpp
  group Src_Application_DeviceComponent
    ./Src/Application/DeviceComponent/: CAttributeFlash.cpp CDeviceAttribute.cpp CISAP100Factory.cpp CInterfaceCardCreatFactory.cpp CNandFlash.cpp DeviceLocal.cpp CMainBoard.cpp CLoopModule.cpp CEMUX10Factory.cpp CTMFactory.cpp EthBoard.cpp
  group Src_Application_DeviceComponent_BusinessResource_E1Module
    ./Src/Application/DeviceComponent/BusinessResource/E1Module/: CE1BufferDeepthChecker.cpp CUnframeE1.cpp CE1Channel.cpp CUInterface.cpp CUpE1Port.cpp CNME1Port.cpp
  group Src_Application_DeviceComponent_CrossConnectionModule
    ./Src/Application/DeviceComponent/CrossConnectionModule/: CCrossConnection.cpp CVC12CrossConnectionMagager.cpp CTSCrossConnectionManager.cpp
  group Src_Application_DeviceComponent_SlotCard
    ./Src/Application/DeviceComponent/SlotCard/: CBaseCard.cpp CBaseSlot.cpp CExtCard4E1.cpp CExtCard8VF.cpp CSlotManager.cpp CCardOnlineChecker.cpp CIsapSlot.cpp CIsap100HardwareDesc.cpp CPowerCard.cpp CPowerSlot.cpp CExtCard8Data.cpp CExtCard2BD.cpp
  group Src_Application_Reference_Hardware
    ./Src/Application/Reference/Hardware/: CE1FPGAImpl.cpp
  group Src_Application_Reference_Hardware_SaveInterface
    ./Src/Application/Reference/Hardware/SaveInterface/: CAttributeSave.cpp
  group Src_Application_Tools
    ./Src/Application/Tools/: CCheckData.cpp fixaddr.c UID.cpp RTC.cpp TraceCounter.cpp CPPTools.cpp EthMemory.c SysError.cpp net_api.c
  group Src_SNMP_SNMPMib_Private_ElementGroup
    ./Src/SNMP/SNMPMib/Private/ElementGroup/: CMibNEStruct.cpp GroupCardList.cpp GroupDeviceList.cpp GroupTopology.cpp NEStructGroup.cpp TableDevice.cpp TableSlot.cpp TableTopoOption.cpp TableTopoStatus.cpp
  group Src_SNMP_SNMPMib_Private_InterfaceGroup
    ./Src/SNMP/SNMPMib/Private/InterfaceGroup/: CMibInterface.cpp CMibVC12.cpp CMibVC12Port.cpp CMibSTM.cpp CMibSTMConfig.cpp CMibSTMOverheadTable.cpp CMibE1PortTable.cpp CMibSTMAlarmProperty.cpp CMibE1.cpp CMibE1AlarmPropertyTable.cpp CMibE1ChannelTable.cpp CMibTS.cpp CMibTSChannelTable.cpp CMibVFPortTable.cpp CMibVcgConfigTable.cpp CMibVcgGroup.cpp CMibVcgMemberTable.cpp CMibDataPortTable.cpp CMibUPortTable.cpp CMibETH.cpp CMibETHPortTable.cpp CMibNMPortGroup.cpp CMibNMPortTable.cpp CMibXE1.cpp CMibXE1AlarmPropertyTable.cpp CMibXE1PortTable.cpp
  group Src_SNMP_SNMPMib_Private_DebugGroup
    ./Src/SNMP/SNMPMib/Private/DebugGroup/: CMibDebug.cpp
  group Src_Application_DeviceComponent_BusinessResource_SDHModule
    ./Src/Application/DeviceComponent/BusinessResource/SDHModule/: CSTM.cpp CVC12.cpp SDHGroup.cpp
  group Src_SNMP_SNMPMib_Private_ModuleGroup
    ./Src/SNMP/SNMPMib/Private/ModuleGroup/: CMibModule.cpp CMibFunctionModuleGroup.cpp CMibMappingAddTable.cpp CMibMappingProperty.cpp CMibXCAddTable.cpp CMibXCProperty.cpp CMibLoopAddTable.cpp CMibLoopPropertyTable.cpp CMibLoopablePortTable.cpp CMibBaseSwitchFunction.cpp
  group Src_Application_DeviceComponent_Chips
    ./Src/Application/DeviceComponent/Chips/: SlotLogicLX9.cpp Lpc3250upload.cpp
  group Src_UpDataMain
    ./Src/UpDataMain/: cfg_save_nand.c
  group Src_Application_DeviceComponent_BusinessResource_EthModule
    ./Src/Application/DeviceComponent/BusinessResource/EthModule/: CVCG.cpp CVCGGroup.cpp CVCGMember.cpp PortEth.cpp SwitchModule.cpp
  group Src_Application_AlarmSite
    ./Src/Application/AlarmSite/: AlarmAUSite.cpp AlarmHPSite.cpp AlarmLPSite.cpp AlarmMSSite.cpp AlarmTUSite.cpp AlarmVCGSite.cpp AlarmUnframeE1site.cpp AlarmVCGMemberSite.cpp AlarmNmPortE1Site.cpp AlarmUpE1Port.cpp
  group Src_Application_DeviceComponent_BusinessResource_TSModule
    ./Src/Application/DeviceComponent/BusinessResource/TSModule/: CSTBus.cpp CTSChannel.cpp CTSE1.cpp CVFPort.cpp CDataPort.cpp
  group Src_Application_AlarmModule
    ./Src/Application/AlarmModule/: AlarmItem.cpp SingleCurrentAlarm.cpp SingleHistoryAlarm.cpp
  group Src_SNMP_SNMPMib_Private_AlarmGroup
    ./Src/SNMP/SNMPMib/Private/AlarmGroup/: AlarmGroup.cpp AlarmNumberTable.cpp AlarmPropertyGlobalTable.cpp CurrentAlarmTable.cpp HistoryAlarmTable.cpp
  group Src_Application_SoftSwitch
    ./Src/Application/SoftSwitch/: CFinishedPacket.cpp MacPortMap.cpp PriPacket.cpp SwitchCore.cpp SwitchPort.cpp SwitchPortCPU.cpp SwitchPortInner.cpp SwitchPortStd.cpp switchPortSNMP.cpp Layer2Tag.cpp DCCChannelRcv.cpp DCCChannelSnd.cpp DCCSdhRcv.cpp DCCSdhSnd.cpp InnerDCCManager.cpp DCNXe1Rcv.cpp DCNXe1Snd.cpp UpE1DCNChannelRcv.cpp UpE1DCNChannelSnd.cpp UpE1SabitChannelRcv.cpp UpE1SabitChannelSnd.cpp
  group Src_Application_TopologyModule
    ./Src/Application/TopologyModule/: TopoManager.cpp
  group Src_SNMP_SNMPMib_Private_Performance
    ./Src/SNMP/SNMPMib/Private/Performance/: PerformanceEthPortTable.cpp PerformanceGroup.cpp
